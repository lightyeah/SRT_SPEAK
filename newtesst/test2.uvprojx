# Keil uVision project test2.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: test2
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ::Board Support
    d:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Boards/Keil/MCBSTM32C/Common/: ADC.c GLCD_SPI_STM32F10x.c Joystick.c Keyboard.c LED.c Touch_STMPE811.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    d:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
    d:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group ::Device
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
    d:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    d:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
  group ::Drivers
    RTE/Drivers/: NAND_MemBus_Config.h OneNAND_Config.h
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/FileSystem/Driver/NAND/: NAND_MemBus.c OneNAND.c
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/FileSystem/Driver/NOR/AM29x800BB/: NOR_AM29x800BB.c
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/FileSystem/Driver/NOR/M29W640FB/: NOR_M29W640FB.c
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/FileSystem/Driver/NOR/S29GL064Nx2/: NOR_S29GL064Nx2.c
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/Network/Driver/: PHY_DP83848C.c PHY_ST802RT1.c
    d:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/RTE_Driver/: I2C_STM32F10x.c MCI_STM32F10x.c
  group ::Graphics
    RTE/Graphics/: GUIConf.c
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/emWin/Lib/ARM/: GUI_CM3_L.lib
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/emWin/Sample/GUI_X/: GUI_X_RTE.c
  group ::Network
    RTE/Network/: Net_Config.c Net_Debug.c
    d:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/5.1.4/Network/Lib/ARM/: Net_Dbg_CM3_L.lib
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:MCBSTM32C:A/D Converter 1.0.0, Board Support:MCBSTM32C:Graphic LCD 1.0.0, Board Support:MCBSTM32C:Joystick 1.0.0, Board Support:MCBSTM32C:Keyboard 1.0.0, Board Support:MCBSTM32C:LED 1.0.0, Board Support:MCBSTM32C:Touchscreen 1.0.0, Network:CORE 5.0.4, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0, Drivers:Ethernet MAC 1.02.0, Drivers:Ethernet PHY:DP83848C 5.01.0, Drivers:Ethernet PHY:ST802RT1 5.01.0, Drivers:I2C 1.01.0, Drivers:MCI 1.01.0, Drivers:NAND:Memory Bus 5.04.0, Drivers:NAND:OneNAND 5.04.0, Drivers:NOR:AM29x800BB 5.04.0, Drivers:NOR:M29W640FB 5.04.0, Drivers:NOR:S29GL064Nx2 5.04.0, Graphics:CORE 5.22.1
