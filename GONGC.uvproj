# Keil uVision project GONGC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GONGC +hex
  c flags: Optim=1
  c include: .\source\wlib\delay;.\source\wlib\SYS;.\source\wlib\USART;.\source\FWLib\inc;.\user;.\source\wlib\Switch;.\source\wlib\Motor;.\GPIO_Config;.\PWM_Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ./source/startup/: cortexm3_macro.s startup_stm32f10x_hd.s
  group user
    ./user/: main.c
    ./source/wlib/TICK/: System_Tick.c
    ./GPIO_Config/: GPIO_Config.c
    ./PWM_Config/: PWM_Config.c
  group lib
    ./source/FWLib/src/: stm32f10x_tim.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_nvic.c stm32f10x_exti.c
    ./source/wlib/delay/: delay.c
    ./source/wlib/SYS/: RCC_Configuration.c
    ./source/wlib/USART/: USART_Configuration.c
